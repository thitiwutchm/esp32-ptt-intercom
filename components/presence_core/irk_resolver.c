#include "irk_resolver.h"

#include <string.h>

/* ------------------------------------------------------------------ AES-128 (encrypt one block)
 *
 * Textbook AES-128, enough for the 16-byte block the BLE hash needs. Keys and
 * blocks here are big-endian (byte 0 most significant), the order the BLE
 * security functions are defined in. Kept self-contained like voip_core/md5.c
 * so the host tests need no crypto library.
 */

static const uint8_t SBOX[256] = {
    0x63, 0x7c, 0x77, 0x7b, 0xf2, 0x6b, 0x6f, 0xc5, 0x30, 0x01, 0x67, 0x2b, 0xfe, 0xd7, 0xab, 0x76,
    0xca, 0x82, 0xc9, 0x7d, 0xfa, 0x59, 0x47, 0xf0, 0xad, 0xd4, 0xa2, 0xaf, 0x9c, 0xa4, 0x72, 0xc0,
    0xb7, 0xfd, 0x93, 0x26, 0x36, 0x3f, 0xf7, 0xcc, 0x34, 0xa5, 0xe5, 0xf1, 0x71, 0xd8, 0x31, 0x15,
    0x04, 0xc7, 0x23, 0xc3, 0x18, 0x96, 0x05, 0x9a, 0x07, 0x12, 0x80, 0xe2, 0xeb, 0x27, 0xb2, 0x75,
    0x09, 0x83, 0x2c, 0x1a, 0x1b, 0x6e, 0x5a, 0xa0, 0x52, 0x3b, 0xd6, 0xb3, 0x29, 0xe3, 0x2f, 0x84,
    0x53, 0xd1, 0x00, 0xed, 0x20, 0xfc, 0xb1, 0x5b, 0x6a, 0xcb, 0xbe, 0x39, 0x4a, 0x4c, 0x58, 0xcf,
    0xd0, 0xef, 0xaa, 0xfb, 0x43, 0x4d, 0x33, 0x85, 0x45, 0xf9, 0x02, 0x7f, 0x50, 0x3c, 0x9f, 0xa8,
    0x51, 0xa3, 0x40, 0x8f, 0x92, 0x9d, 0x38, 0xf5, 0xbc, 0xb6, 0xda, 0x21, 0x10, 0xff, 0xf3, 0xd2,
    0xcd, 0x0c, 0x13, 0xec, 0x5f, 0x97, 0x44, 0x17, 0xc4, 0xa7, 0x7e, 0x3d, 0x64, 0x5d, 0x19, 0x73,
    0x60, 0x81, 0x4f, 0xdc, 0x22, 0x2a, 0x90, 0x88, 0x46, 0xee, 0xb8, 0x14, 0xde, 0x5e, 0x0b, 0xdb,
    0xe0, 0x32, 0x3a, 0x0a, 0x49, 0x06, 0x24, 0x5c, 0xc2, 0xd3, 0xac, 0x62, 0x91, 0x95, 0xe4, 0x79,
    0xe7, 0xc8, 0x37, 0x6d, 0x8d, 0xd5, 0x4e, 0xa9, 0x6c, 0x56, 0xf4, 0xea, 0x65, 0x7a, 0xae, 0x08,
    0xba, 0x78, 0x25, 0x2e, 0x1c, 0xa6, 0xb4, 0xc6, 0xe8, 0xdd, 0x74, 0x1f, 0x4b, 0xbd, 0x8b, 0x8a,
    0x70, 0x3e, 0xb5, 0x66, 0x48, 0x03, 0xf6, 0x0e, 0x61, 0x35, 0x57, 0xb9, 0x86, 0xc1, 0x1d, 0x9e,
    0xe1, 0xf8, 0x98, 0x11, 0x69, 0xd9, 0x8e, 0x94, 0x9b, 0x1e, 0x87, 0xe9, 0xce, 0x55, 0x28, 0xdf,
    0x8c, 0xa1, 0x89, 0x0d, 0xbf, 0xe6, 0x42, 0x68, 0x41, 0x99, 0x2d, 0x0f, 0xb0, 0x54, 0xbb, 0x16};

static const uint8_t RCON[10] = {0x01, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x1b, 0x36};

static uint8_t xtime(uint8_t x)
{
    return (uint8_t)((x << 1) ^ ((x >> 7) * 0x1b));
}

static void aes128_encrypt(const uint8_t key[16], const uint8_t in[16], uint8_t out[16])
{
    uint8_t rk[176];
    memcpy(rk, key, 16);
    for (int i = 16, r = 0; i < 176; i += 4) {
        uint8_t t[4];
        memcpy(t, rk + i - 4, 4);
        if (i % 16 == 0) {
            uint8_t tmp = t[0];
            t[0] = (uint8_t)(SBOX[t[1]] ^ RCON[r++]);
            t[1] = SBOX[t[2]];
            t[2] = SBOX[t[3]];
            t[3] = SBOX[tmp];
        }
        for (int j = 0; j < 4; j++) {
            rk[i + j] = (uint8_t)(rk[i - 16 + j] ^ t[j]);
        }
    }

    uint8_t s[16];
    memcpy(s, in, 16);
    for (int i = 0; i < 16; i++) {
        s[i] ^= rk[i];
    }
    for (int round = 1; round <= 10; round++) {
        for (int i = 0; i < 16; i++) {
            s[i] = SBOX[s[i]];
        }
        /* ShiftRows (state is column-major: byte index = col*4 + row). */
        uint8_t t;
        t = s[1]; s[1] = s[5]; s[5] = s[9]; s[9] = s[13]; s[13] = t;
        t = s[2]; s[2] = s[10]; s[10] = t; t = s[6]; s[6] = s[14]; s[14] = t;
        t = s[15]; s[15] = s[11]; s[11] = s[7]; s[7] = s[3]; s[3] = t;
        if (round != 10) {
            for (int c = 0; c < 4; c++) {
                uint8_t *col = s + c * 4;
                uint8_t a0 = col[0], a1 = col[1], a2 = col[2], a3 = col[3];
                uint8_t all = (uint8_t)(a0 ^ a1 ^ a2 ^ a3);
                col[0] ^= all ^ xtime((uint8_t)(a0 ^ a1));
                col[1] ^= all ^ xtime((uint8_t)(a1 ^ a2));
                col[2] ^= all ^ xtime((uint8_t)(a2 ^ a3));
                col[3] ^= all ^ xtime((uint8_t)(a3 ^ a0));
            }
        }
        for (int i = 0; i < 16; i++) {
            s[i] ^= rk[round * 16 + i];
        }
    }
    memcpy(out, s, 16);
}

/* ------------------------------------------------------------------ BLE address resolution */

void irk_ah(const uint8_t irk[16], const uint8_t prand[3], uint8_t out[3])
{
    /* ah(k, r) = e(k, r)[low 24 bits]. k and r are big-endian; the stored IRK
     * is little-endian, so reverse it. r' is prand in the low 24 bits of a
     * 128-bit block (the rest zero). */
    uint8_t key[16], block[16] = {0}, cipher[16];
    for (int i = 0; i < 16; i++) {
        key[i] = irk[15 - i];
    }
    block[13] = prand[2];
    block[14] = prand[1];
    block[15] = prand[0];
    aes128_encrypt(key, block, cipher);
    out[0] = cipher[15];
    out[1] = cipher[14];
    out[2] = cipher[13];
}

bool irk_addr_is_rpa(const uint8_t addr[6])
{
    return (addr[5] & 0xC0) == 0x40; /* most significant two bits == 0b01 */
}

bool irk_resolve(const uint8_t irk[16], const uint8_t addr[6])
{
    if (!irk_addr_is_rpa(addr)) {
        return false;
    }
    /* RPA = prand(top 24 bits) || hash(low 24 bits). In little-endian val[],
     * prand = val[5..3], hash = val[2..0]. */
    uint8_t prand[3] = {addr[3], addr[4], addr[5]};
    uint8_t h[3];
    irk_ah(irk, prand, h);
    return h[0] == addr[0] && h[1] == addr[1] && h[2] == addr[2];
}
